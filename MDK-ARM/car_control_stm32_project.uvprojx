# Keil uVision project car_control_stm32_project.uvprojx, settings and files
target car_control_stm32_project (6070000::V6.7::.\ARMCLANG)
  device: STM32G474VBTx STMicroelectronics
  pack: Keil.STM32G4xx_DFP.1.4.0
  cpu: IRAM(0x20000000-0x2001FFFF) IROM(0x8000000-0x801FFFF) CLOCK(8000000) FPU2 CPUTYPE("Cortex-M4") TZ
  output: car_control_stm32_project +hex
  c flags: Optim=2 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: USE_HAL_DRIVER,STM32G474xx
  c include: ../Core/Inc;../Drivers/STM32G4xx_HAL_Driver/Inc;../Drivers/STM32G4xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32G4xx/Include;../Drivers/CMSIS/Include;../User/Device;../User/It;../User/Motor;../User/Sensor;../User/Status;../User/Tool
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x20000
  scatter file: stm32g474xx_flash.sct
  group Application/MDK-ARM
    ./: startup_stm32g474xx.s
  group Application/User/Core
    ../Core/Src/: lora.c main.c gpio.c adc.c dma.c i2c.c spi.c tim.c usart.c stm32g4xx_it.c stm32g4xx_hal_msp.c
  group Drivers/STM32G4xx_HAL_Driver
    ../Drivers/STM32G4xx_HAL_Driver/Src/: stm32g4xx_hal_adc.c stm32g4xx_hal_adc_ex.c stm32g4xx_ll_adc.c stm32g4xx_hal.c stm32g4xx_hal_rcc.c stm32g4xx_hal_rcc_ex.c stm32g4xx_hal_flash.c stm32g4xx_hal_flash_ex.c stm32g4xx_hal_flash_ramfunc.c stm32g4xx_hal_gpio.c stm32g4xx_hal_exti.c stm32g4xx_hal_dma.c stm32g4xx_hal_dma_ex.c stm32g4xx_hal_pwr.c stm32g4xx_hal_pwr_ex.c stm32g4xx_hal_cortex.c stm32g4xx_hal_i2c.c stm32g4xx_hal_i2c_ex.c stm32g4xx_hal_spi.c stm32g4xx_hal_spi_ex.c stm32g4xx_hal_tim.c stm32g4xx_hal_tim_ex.c stm32g4xx_hal_uart.c stm32g4xx_hal_uart_ex.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32g4xx.c
  group Device
    ../User/Device/: button.c button.h led.c led.h buzzer.c buzzer.h device_test.c
  group It
    ../User/It/: timer_it.c uart_it.c uart_it.h
  group Status
    ../User/Status/: status.c status.h Defect.c
  group Sensor
    ../User/Sensor/: abslute_angle_sensor.c abslute_angle_sensor.h gy901.c gy901.h uart_gyro.c uart_gyro.h maixcam.c maixcam.h ms_find_line.c ms_find_line.h radar.c radar.h gw_anagloge.h gw_analogue.c
  group Motor
    ../User/Motor/: lq_step.c lq_step.h Emm_v5.c Emm_v5.h datou.c datou.h yuntai.c yuntai.h servo.c servo.h wheel.h wheel.c
  group Tool
    ../User/Tool/: array.c array.h eeprom.c eeprom.h log.c log.h math_tool.h pid.c pid.h task.h
software components: CMSIS:CORE 6.1.0
